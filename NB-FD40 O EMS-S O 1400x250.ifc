Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-12T14:37:37+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingElementProxy: NLRS_57_DUA_UN_rectangular firedamper fd40_sacs:FD40 O EMS-S O, NLRS_57_DUA_UN_rectangular firedamper fd40_sacs:FD40 O EMS-S O:1045777
In: Default
Type - Description: Rechthoekige brandklep; Classification: 57.70 (Uniformat); Material: NLRS_A_SACS_SVZ (3)
Type - Constraints - Default Elevation: 0 mm
Type - General - Article_Codes: FD40_Article_Codes; Factors: FD40_Factors
Type - Identity Data - Assembly Code: 57.70; Description: Rechthoekige brandklep; Manufacturer: Solid Air Climate Solutions; Model: Brandklep - Rechthoekig; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 17-02-2022; NLRS_C_content_provider: Solid Air Climate Systems; NLRS_C_content_versie: Versie 3.19.02; NLRS_C_description: Rechthoekige brandklep; NLRS_C_niveau ontwikkeling: LOD400; Type Name: FD40 O EMS-S O; URL: https://solid-air.nl/producten/solid-air-rechthoekige-brandklep-fd40/
Type - Materials and Finishes - Blade material: Promatect, 40mm; Casing material: Galvanized Steel; Fuse temperatuur (default): 72 degrees Celsius
Type - Other - Category: Duct Accessories; Family Name: NLRS_57_DUA_UN_rectangular firedamper fd40_sacs
Type - Visibility - SACS_Show_Symbol: yes
Type - Pset_ConcreteElementGeneral - FireRating: EN 1366-2 and EN 13501-3, 2h
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Duct Accessories
Pset_BuildingElementProxyCommon - Reference: FD40 O EMS-S O; sets with these values: 2
Pset_ProvisionForVoid - Width: 223 mm; Height: 1373 mm; Depth: 40 mm
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.315506 m2; NLRS_C_lengte: 350 mm; NLRS_M_c01_breedte: 1400 mm; NLRS_M_c01_hoogte: 250 mm; SACS_Duct_Height: 250 mm; SACS_Duct_Width: 1400 mm; Volume: 0.00000197509 m3
Graphics - Use Annotation Scale: no
Identity Data - Mark: 8924; NLRS_C_model: FD40 O EMS-S O 1400x250; SACS_Article_Code: NB; SACS_Gross_Cost: 0
Insulation - Insulation Thickness: 0 mm
Lining - Lining Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - NLRS_M_c01_debiet: 0 m3/s; NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Air_Velocity: 0 m/s; SACS_Lp_dBA: 0; SACS_Manual_Airflow: 0 m3/s; SACS_Nominal_Max_Flow: 3500 m3/s; SACS_Nominal_Min_Flow: 700 m3/s; SACS_Use_Manual_Airflow: no
Model Properties - SACS_Belimo_Rotation (1-2): 1; SACS_Option_1: O = geen frame; SACS_Option_2: EMS-S = Kleefmagneet, met eindschakelaars; SACS_Option_3: O = Geen Accessoire
Other - Family: NLRS_57_DUA_UN_rectangular firedamper fd40_sacs; Family and Type: NLRS_57_DUA_UN_rectangular firedamper fd40_sacs: FD40 O EMS-S O; Type: FD40 O EMS-S O; Type Id: 991833
Phasing - Phase Created: New Construction
Visibility - SACS_Disable_Warning: no

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
